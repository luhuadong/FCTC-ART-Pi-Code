# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: RT_USING_DLIBC; STM32H750xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: board/CubeMX_Config/Core/Inc; rt-thread/components/libc/compilers/common; rt-thread/components/libc/posix/io/stdio; .; libraries/STM32H7xx_HAL/CMSIS/Include; rt-thread/components/drivers/include; rt-thread/components/libc/posix/io/poll; rt-thread/components/finsh; rt-thread/libcpu/arm/cortex-m7; libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Inc; rt-thread/libcpu/arm/common; rt-thread/components/libc/posix/ipc; board; rt-thread/include; libraries/HAL_Drivers/config; board/port; rt-thread/components/libc/compilers/common/extension; libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Include; libraries/HAL_Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
    rt-thread/components/libc/compilers/dlib/: syscall_remove.c syscall_lseek.c syscall_mem.c syscall_read.c syscall_open.c syscall_write.c syscalls.c environ.c syscall_close.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c div0.c backtrace.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/ipc/: ringbuffer.c completion.c dataqueue.c workqueue.c pipe.c waitqueue.c ringblk_buf.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/HAL_Drivers/: drv_usart.c drv_common.c drv_gpio.c
  group Finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: components.c mempool.c scheduler.c timer.c irq.c mem.c object.c thread.c idle.c clock.c kservice.c device.c ipc.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_usart.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_sram.c stm32h7xx_hal_dma.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cec.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
